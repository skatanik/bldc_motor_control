# Keil uVision project prj_v2.uvprojx, settings and files
target prj_v2 (ARM-ADS)
  device: STM32G431RBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: prj_v2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,USE_HAL_DRIVER,STM32G431xx,USE_FULL_LL_DRIVER
  c include: ../Inc;                                      ../Drivers/STM32G4xx_HAL_Driver/Inc;                                      ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                                      ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                                      ../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
